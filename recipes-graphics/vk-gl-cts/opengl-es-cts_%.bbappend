require ../../../meta-aaeon-mtk/recipes-graphics/vk-gl-cts/khronos-cts.inc
